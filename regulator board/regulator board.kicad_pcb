# Repository Lenart12/kresnik

File readme.md:

# Solar and Underfloor Heating Regulation Controller

## Overview

This project is a sophisticated heating system controller designed to manage up to 18 relays and 4 motors.
It utilizes DS18XXX temperature sensors for precise thermal regulation and offers WiFi capabilities for remote monitoring and control.
The system features an intuitive touchscreen interface along with physical buttons for ease of use.

Its core functionalities of this controller is managing a Buderus furnace and a domestic hot water (DHW) storage tank. By integrating with these components, the system ensures optimal heating efficiency and consistent hot water availability. The controller can intelligently switch between different heating modes, regulate the temperature of the furnace, and maintain the desired temperature in the DHW storage tank. This comprehensive control mechanism not only enhances comfort but also contributes to energy savings by optimizing the heating cycles and reducing unnecessary energy consumption.

## Project Structure

- **buderus-controller**: Contains the newest simplified controller.
- **esp32-HRC**: The older version of the project.
- **regulator board**: KiCAD PCB design project.

## Schema

## PCB Design

## KiCad design regulator board/regulator board.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6: 100nF; C_Rect_L7.0mm_W2.0mm_P5.00mm
C7, C8, C9, C10, C11, C12, C13, C14: 0.01uF; C_Rect_L18.0mm_W5.0mm_P15.00mm_FKS3_FKP3
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16: LED; LED_D5.0mm
J1: C14 socket https://bit.ly/2kjjjZt; SolderWirePad_1x03_P5.715mm_Drill2mm
J2, J4, J5, J6: Phoenix connector 01x04; PhoenixContact_MSTBVA_2,5_4-G_1x04_P5.00mm_Vertical
J3: Pin socket; PinSocket_1x04_P2.54mm_Vertical
J7, J9, J10: Conn_01x02_Female; PinSocket_1x02_P2.54mm_Vertical
J8: Conn_01x16_Female; PinSocket_1x16_P2.54mm_Vertical
PS1: Power supply https://bit.ly/2kBfKOu; Converter_ACDC_HiLink_HLK-PMxx
Q1, Q2, Q3: BSS84; SOT-23
R1, R3, R5, R8, R10, R12, R16, R18: 330; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R2, R4, R7, R9, R11, R13, R17, R19: 39; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R6, R29, R31, R32, R33: 10K; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R14, R15: 4k7; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R20, R21, R22, R24, R25, R26, R27, R28: 180; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R23, R30: 100; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
RV1: Varistor; RV_Disc_D12mm_W3.9mm_P7.5mm
SW1, SW2: SW_Push_Dual; SW_TH_Tactile_Omron_B3F-10xx
SW3, SW4, SW5, SW6: SW_Push_Dual; Push_E-Switch_KS01Q01
TFT1: SPI TFT https://bit.ly/2lMnf5f; SPI_TFT
U1, U4, U5, U6, U7, U9, U10, U11: MOC3063M; DIP-6_W7.62mm_Socket
U2: LM1117SX-3.3; TO-263-3_TabPin2
U3, U12, U13, U16: PCF8574P https://bit.ly/2mbALiV; DIP-16_W7.62mm
U8: ESP-32S https://bit.ly/2kIsByf; ESP32-WROOM-32
U14, U15: DS2482S-100; SOP-8_3.76x4.96mm_P1.27mm

Connections:
+3V3: C5.1, C6.1, J3.1, Q1.3 (D), R6.1, R14.1, R15.1, R29.2, R31.2, R32.2, R33.2, TFT1.14 (VCC), U2.2, U8.2 (VDD)
+5V: C1.1, C2.1, C3.1, C4.1, J7.1, J9.1, PS1.4 (+Vout), R1.2, R3.2, R5.2, R8.2, R10.2, R12.2, R16.2, R18.2, R20.1, R21.1, R22.1, R23.1, R24.1, R25.1, R26.1, R27.1, R28.1, R30.1, U2.3, U3.1 (A0), U3.16 (VDD), U12.16 (VDD), U13.2 (A1), U13.16 (VDD), U14.1 (VCC), U15.1 (VCC), U15.8 (AD0), U16.1 (A0), U16.2 (A1), U16.16 (VDD)
/EN: R6.2, SW1.4, U8.3 (EN)
/K1: R29.1, SW3.1, U8.4 (SENSOR_VP)
/K2: R31.1, SW4.1, U8.5 (SENSOR_VN)
/K3: R32.1, SW5.1, U8.6 (IO34)
/K4: R33.1, SW6.1, U8.7 (IO35)
/P1: U1.2, U3.4 (P0)
/P2: U3.5 (P1), U4.2
/P3: U3.6 (P2), U5.2
/P4: U3.7 (P3), U6.2
/P5: U3.9 (P4), U7.2
/P6: U3.10 (P5), U9.2
/P7: U3.11 (P6), U10.2
/P8: U3.12 (P7), U11.2
/R1: J8.1, U13.4 (P0)
/R2: J8.2, U13.5 (P1)
/R3: J8.3, U13.6 (P2)
/R4: J8.4, U13.7 (P3)
/R5: J8.5, U13.9 (P4)
/R6: J8.6, U13.10 (P5)
/R7: J8.7, U13.11 (P6)
/R8: J8.8, U13.12 (P7)
/R9: J8.9, U16.4 (P0)
/R10: J8.10, U16.5 (P1)
/R11: J8.11, U16.6 (P2)
/R12: J8.12, U16.7 (P3)
/R13: J8.13, U16.9 (P4)
/R14: J8.14, U16.10 (P5)
/R15: J8.15, U16.11 (P6)
/R16: J8.16, U16.12 (P7)
/RST: SW2.1, U8.25 (IO0)
/RX: J3.4, U8.34 (RXD0/IO3)
/SD_CS: TFT1.15 (SD_CS), U8.26 (IO4)
/TFT_CS: TFT1.12 (TFT_CS), U8.29 (IO5)
/TFT_DC: TFT1.10 (TFT_D/C), U8.27 (IO16)
/TFT_LED: Q1.1 (G), U8.12 (IO27)
/TFT_RST: TFT1.11 (TFT_RESET), U8.28 (IO17)
/TX: J3.3, U8.35 (TXD0/IO1)
/T_CS: TFT1.4 (T_CS), U8.9 (IO33)
/T_DIN: TFT1.3 (T_DIN), U8.8 (IO32)
/T_DO: TFT1.2 (T_D0), U8.11 (IO26)
/T_IRQ: TFT1.1 (T_IRQ), U8.10 (IO25)
CLK: TFT1.5 (T_CLK), TFT1.8 (TFT_SCK), TFT1.18 (SD_SCK), U8.30 (IO18)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, J3.2, J7.2, J9.2, PS1.3 (-Vout), SW1.1, SW2.4, SW3.4, SW4.4, SW5.4, SW6.4, TFT1.13 (GND), U2.1, U3.2 (A1), U3.3 (A2), U3.8 (VSS), U8.1 (GND), U8.15 (GND), U8.38 (GND), U12.1 (A0), U12.2 (A1), U12.3 (A2), U12.8 (VSS), U13.1 (A0), U13.3 (A2), U13.8 (VSS), U14.3 (GND), U14.7 (AD1), U14.8 (AD0), U15.3 (GND), U15.7 (AD1), U16.3 (A2), U16.8 (VSS)
GNDPWR: J1.3 (EARTH), J2.4, J4.4, J5.4, J6.4
LINE: J1.1 (AC_P), PS1.1 (AC/L), RV1.2, U1.6, U4.6, U5.6, U6.6, U7.6, U9.6, U10.6, U11.6
MISO: TFT1.6 (TFT_MISO), TFT1.17 (SD_MISO), U8.31 (IO19)
MOSI: TFT1.9 (TFT_MOSI), TFT1.16 (SD_MOSI), U8.37 (IO23)
NEUT: C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, J1.2 (AC_N), J2.2, J4.2, J5.2, J6.2, PS1.2 (AC/N), RV1.1
unnamed: C7.2, R2.2
unnamed: C8.2, R4.2
unnamed: C9.2, R7.2
unnamed: C10.2, R9.2
unnamed: C11.2, R11.2
unnamed: C12.2, R13.2
unnamed: C13.2, R17.2
unnamed: C14.2, R19.2
unnamed: D1.1 (K), U1.1
unnamed: D1.2 (A), R1.1
unnamed: D2.1 (K), U4.1
unnamed: D2.2 (A), R3.1
unnamed: D3.1 (K), U5.1
unnamed: D3.2 (A), R5.1
unnamed: D4.1 (K), U6.1
unnamed: D4.2 (A), R8.1
unnamed: D5.1 (K), U7.1
unnamed: D5.2 (A), R10.1
unnamed: D6.1 (K), U9.1
unnamed: D6.2 (A), R12.1
unnamed: D7.1 (K), U10.1
unnamed: D7.2 (A), R16.1
unnamed: D8.1 (K), U11.1
unnamed: D8.2 (A), R18.1
unnamed: D9.1 (K), U12.4 (P0)
unnamed: D9.2 (A), R20.2
unnamed: D10.1 (K), U12.5 (P1)
unnamed: D10.2 (A), R21.2
unnamed: D11.1 (K), U12.6 (P2)
unnamed: D11.2 (A), R22.2
unnamed: D12.1 (K), U12.7 (P3)
unnamed: D12.2 (A), R24.2
unnamed: D13.1 (K), U12.9 (P4)
unnamed: D13.2 (A), R25.2
unnamed: D14.1 (K), U12.10 (P5)
unnamed: D14.2 (A), R26.2
unnamed: D15.1 (K), U12.11 (P6)
unnamed: D15.2 (A), R27.2
unnamed: D16.1 (K), U12.12 (P7)
unnamed: D16.2 (A), R28.2
unnamed: J2.1, R2.1, U1.4
unnamed: J2.3, R4.1, U4.4
unnamed: J4.1, R7.1, U5.4
unnamed: J4.3, R9.1, U6.4
unnamed: J5.1, R11.1, U7.4
unnamed: J5.3, R13.1, U9.4
unnamed: J6.1, R17.1, U10.4
unnamed: J6.3, R19.1, U11.4
unnamed: J10.1, Q2.2 (S), U14.2 (IO)
unnamed: J10.2, Q3.2 (S), U15.2 (IO)
unnamed: Q1.2 (S), TFT1.7 (TFT_LED)
unnamed: Q2.1 (G), U14.6 (PCTLZ)
unnamed: Q2.3 (D), R23.2
unnamed: Q3.1 (G), U15.6 (PCTLZ)
unnamed: Q3.3 (D), R30.2
SCL: R15.2, U3.14 (SCL), U8.36 (IO22), U12.14 (SCL), U13.14 (SCL), U14.4 (SCL), U15.4 (SCL), U16.14 (SCL)
SDA: R14.2, U3.15 (SDA), U8.33 (IO21), U12.15 (SDA), U13.15 (SDA), U14.5 (SDA), U15.5 (SDA), U16.15 (SDA)

Notes on the sheet:
Boot
Enable
Serial I/O
AC 220V-DC 5V
Left Neutral Right Earth
Status indicators
Display
Keyboard
Pump switch
Power supply
Tempature sensor controler
Ground Floor

Board: 2 copper layers, 176.5 x 132.0 mm, 101 parts (0 on the bottom side), 107 nets.

## KiCad design kicad/Relay control/optocupler.kicad_pcb

Parts:
A1: Arduino_Nano_v3.x; Arduino_Nano
C1, C2, C3, C4, C5, C6, C7, C8: C; C_Axial_L17.0mm_D6.5mm_P20.00mm_Horizontal
C9, C10, C11: C; C_Disc_D4.7mm_W2.5mm_P5.00mm
D1, D2, D3, D4, D5, D6, D7, D8: LED; LED_D5.0mm
D9, D10: D_Shockley; D_A-405_P10.16mm_Horizontal
F1, F2: Fuse; Fuseholder_Cylinder-5x20mm_Stelvio-Kontek_PTF78_Horizontal_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
J1: Conn_01x10_Female; PinSocket_1x10_P2.54mm_Vertical
J2, J8: Conn_01x04_Female; PinSocket_1x04_P2.54mm_Vertical
J3, J9: Conn_01x03_Female; JST_NV_B03P-NV_1x03_P5.00mm_Vertical
J4, J5, J6, J7: Conn_01x04_Male; JST_NV_B04P-NV_1x04_P5.00mm_Vertical
Q1: BS170; TO-92_Inline
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20: R; R_Axial_DIN0411_L9.9mm_D3.6mm_P12.70mm_Horizontal
RV1: Varistor; RV_Disc_D15.5mm_W4mm_P7.5mm
U1, U2, U3, U4, U5, U6, U7, U8: NSL-32; DIP-5-6_W7.62mm_LongPads

Connections:
unnamed: A1.1 (D1/TX), J2.1
unnamed: A1.2 (D0/RX), J2.2
unnamed: A1.3 (RESET), J2.5
unnamed: A1.5 (D2), J1.9
unnamed: A1.6 (D3), J1.8
unnamed: A1.7 (D4), J1.7
unnamed: A1.8 (D5), J1.6
unnamed: A1.9 (D6), J1.5
unnamed: A1.10 (D7), J1.4
unnamed: A1.11 (D8), J1.3
unnamed: A1.12 (D9), J1.2
unnamed: A1.13 (D10), J8.3
unnamed: A1.14 (D11), J8.2
unnamed: A1.15 (D12), R17.2
unnamed: A1.16 (D13), D9.2 (A), D10.1 (K), R18.1, R20.2
unnamed: A1.19 (A0), R1.2
unnamed: A1.20 (A1), R2.2
unnamed: A1.21 (A2), R3.2
unnamed: A1.22 (A3), R4.2
unnamed: A1.23 (A4), R5.2
unnamed: A1.24 (A5), R6.2
unnamed: A1.25 (A6), R7.2
unnamed: A1.26 (A7), R8.2
unnamed: A1.27 (+5V), D9.1 (K), F2.1, J1.10, J8.4, R19.1
unnamed: A1.4 (GND), A1.29 (GND), C9.1, C11.2, D10.2 (A), J1.1, J2.4, J8.1, J9.3, Q1.3 (S), U1.2 (K), U2.2 (K), U3.2 (K), U4.2 (K), U5.2 (K), U6.2 (K), U7.2 (K), U8.2 (K)
unnamed: A1.30 (VIN), C9.2, J2.3
unnamed: C1.1, R9.2
unnamed: C1.2, J4.4, U1.4 (R)
unnamed: C2.1, R10.2
unnamed: C2.2, J4.2, U2.4 (R)
unnamed: C3.1, R11.2
unnamed: C3.2, J5.4, U3.4 (R)
unnamed: C4.1, R12.2
unnamed: C4.2, J5.2, U4.4 (R)
unnamed: C5.1, R13.2
unnamed: C5.2, J6.4, U5.4 (R)
unnamed: C6.1, R14.2
unnamed: C6.2, J6.2, U6.4 (R)
unnamed: C7.1, R15.2
unnamed: C7.2, J7.4, U7.4 (R)
unnamed: C8.1, R16.2
unnamed: C8.2, J7.2, U8.4 (R)
unnamed: C10.1, C11.1, Q1.1 (D), R18.2, R19.2
unnamed: C10.2, Q1.2 (G), R17.1
unnamed: D1.1 (K), U2.1 (A)
unnamed: D1.2 (A), R1.1
unnamed: D2.1 (K), U1.1 (A)
unnamed: D2.2 (A), R2.1
unnamed: D3.1 (K), U4.1 (A)
unnamed: D3.2 (A), R3.1
unnamed: D4.1 (K), U3.1 (A)
unnamed: D4.2 (A), R4.1
unnamed: D5.1 (K), U6.1 (A)
unnamed: D5.2 (A), R5.1
unnamed: D6.1 (K), U5.1 (A)
unnamed: D6.2 (A), R6.1
unnamed: D7.1 (K), U8.1 (A)
unnamed: D7.2 (A), R7.1
unnamed: D8.1 (K), U7.1 (A)
unnamed: D8.2 (A), R8.1
unnamed: F1.1, RV1.1, U1.3 (R), U2.3 (R), U3.3 (R), U4.3 (R), U5.3 (R), U6.3 (R), U7.3 (R), U8.3 (R)
unnamed: F1.2, J3.3
unnamed: F2.2, J9.1
unnamed: J3.1, J4.1, J5.1, J6.1, J7.1
unnamed: J3.2, J4.3, J5.3, J6.3, J7.3, R9.1, R10.1, R11.1, R12.1, R13.1, R14.1, R15.1, R16.1, RV1.2
unnamed: J9.2, R20.1

Board: 2 copper layers, 100.0 x 100.0 mm, 63 parts (0 on the bottom side), 66 nets.

## KiCad design kicad/Display/display.kicad_pcb

Board: 2 copper layers, 100.0 x 100.0 mm, 36 parts (15 on the bottom side), 34 nets.

Parts:
C1: CP; CP_Radial_D12.5mm_P5.00mm
C2, C3, C4: C; C_Disc_D4.7mm_W2.5mm_P5.00mm
D1: D_Bridge_+A-A; Diode_Bridge_Round_D9.0mm
D2, D3, D4, D5, D6, D7, D8: LED; LED_D5.0mm
IC1: RaspberryPiZeroW; Raspberry_Pi_Zero_W
J1: Conn_01x02_Female; PhoenixContact_MSTBVA_2,5_2-G-5,08_1x02_P5.08mm_Vertical
J2: Conn_01x05_Female; PinSocket_1x05_P2.54mm_Vertical
R1, R2, R3, R4, R5, R6, R7: R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
SW1, SW2, SW3, SW4: SW_Push_Dual; Push_E-Switch_KS01Q01
TFT**: SPI_TFT
TP1, TP9, TP10, TP11, TP12, TP13, TP14, TP15: TestPoint; TestPoint_Plated_Hole_D2.0mm
U1: LM7805_TO220; TO-220F-3_Horizontal_TabDown

Connections:
+5V: C3.1, C4.1, IC1.2, IC1.4, U1.3
GND: C1.2, C2.2, C3.2, C4.2, D1.3, D2.1, D3.1, D4.1, D5.1, D6.1, D7.1, D8.1, IC1.6, IC1.9, IC1.14, IC1.20, IC1.25, IC1.30, IC1.34, IC1.39, J2.4, SW1.1, SW1.3, SW2.1, SW2.3, SW3.1, SW3.3, SW4.1, SW4.3, U1.2
unnamed: C1.1, C2.1, D1.1, J2.3, U1.1
unnamed: D1.2, J1.1
unnamed: D1.4, J1.2
unnamed: D2.2, R1.1
unnamed: D3.2, R2.1
unnamed: D4.2, R3.1
unnamed: D5.2, R4.1
unnamed: D6.2, R5.1
unnamed: D7.2, R6.1
unnamed: D8.2, R7.1
unnamed: IC1.1, IC1.17, TP1.1
unnamed: IC1.3, R1.2
unnamed: IC1.5, R2.2
unnamed: IC1.7, R3.2
unnamed: IC1.8, J2.1
unnamed: IC1.10, J2.2
unnamed: IC1.13, J2.5
unnamed: IC1.19, R4.2
unnamed: IC1.21, R5.2
unnamed: IC1.23, R6.2
unnamed: IC1.24, R7.2
unnamed: IC1.26, TP9.1
unnamed: IC1.27, TP10.1
unnamed: IC1.28, TP11.1
unnamed: IC1.29, SW4.2, SW4.4
unnamed: IC1.31, SW3.2, SW3.4
unnamed: IC1.32, SW2.2, SW2.4
unnamed: IC1.33, SW1.2, SW1.4
unnamed: IC1.41, TP12.1
unnamed: IC1.42, TP13.1
unnamed: IC1.43, TP14.1
unnamed: IC1.44, TP15.1

## Code that names these connections

File esp32-HRC/include/defines.h:

#ifndef DEFINES_H
#define DEFINES_H

#include <inttypes.h>
#include <lvgl.h>

#define CLEAN_CONFIG 0

#define SIM_TEMPATURE 1

// PINS {
static const uint8_t SD_CS = 4;     // 26

static const uint8_t TFT_LED = 27;  // 12
static const uint8_t TFT_DC = 16;   // 27
static const uint8_t TFT_RST = 17;  // 28
static const uint8_t TFT_CS = 5;    // 29

static const uint8_t SPI_CLK = 18;  // 30
static const uint8_t SPI_MISO = 19; // 31
static const uint8_t SPI_MOSI = 23;  // 37

static const uint8_t I2C_SDA = 21;  // 33
static const uint8_t I2C_SCL = 22;  // 36

static const uint8_t T_DIN = 32;    // 08
static const uint8_t T_CS = 33;     // 09
static const uint8_t T_IRQ = 25;    // 10
static const uint8_t T_DO = 26;     // 11

static const uint8_t BUTTON_0 = 36; // 04
static const uint8_t BUTTON_1 = 39; // 05
static const uint8_t BUTTON_2 = 34; // 06
static const uint8_t BUTTON_3 = 35; // 07

// }

// COLORS {
static const lv_color_t BUTTON_0_COLOR = LV_COLOR_MAKE(  0,   0,   0);
static const lv_color_t BUTTON_1_COLOR = LV_COLOR_MAKE(255, 255, 255);
static const lv_color_t BUTTON_2_COLOR = LV_COLOR_MAKE(255, 255,   0);
static const lv_color_t BUTTON_3_COLOR = LV_COLOR_MAKE(  0,   0, 255);

static const lv_color_t BUTTON_COLORS[]{
	BUTTON_0_COLOR,
	BUTTON_1_COLOR,
	BUTTON_2_COLOR,
	BUTTON_3_COLOR
};
// }

// TFT {
static const uint16_t W = 320;
static const uint16_t H = 240;
static const uint8_t TFT_ROTATION = 1;
static const uint32_t TFT_SCREEN_OFF = 30 * 1000; // 30 seconds

static const uint16_t TOUCH_CALIBRATION[5] = { 174, 3571, 311, 3539, 1 };

static const uint8_t LVGL_TICK_PERIOD = 20;
//}

// BUTTONS {
static const uint8_t BUTTONS[] = {
	BUTTON_0,
	BUTTON_1,
	BUTTON_2,
	BUTTON_3
};
// }

// ADDRESSES {
static const uint8_t DS2482_0 = 0x19;
static const uint8_t DS2482_1 = 0x18;
static const uint8_t PCF8574_STATUS = 0x20;
static const uint8_t PCF8574_THERMO = 0x21;
static const uint8_t PCF8574_RELAY0 = 0x22;
static const uint8_t PCF8574_RELAY1 = 0x23;
// }

// STATUS LEDS {
#define ON LOW
#define OFF HIGH

enum Status_led : uint8_t{
	power = 0,
	wifi = 1,
	moving_motor = 2,
	night_time_s = 3,
	burner_s = 4,
	hot_water_pump_s = 5,
	circulator_s = 6,
	error = 7
};
//}

// RELAY EXPANDER {
enum Relay_pin : uint8_t{
	burner = 0,
	hot_water_pump = 1,
	underfloor_pump_0 = 2,
	underfloor_pump_1 = 3,
	underfloor_pump_2 = 4,
	underfloor_pump_3 = 5,
	circulator_pump = 6,
	solar_pump = 7,
	inter_tank_pump = 8
};
//}

static const uint32_t CONTROL_INTERVAL = 2 * 60 * 1000; // 2 minutes
static const uint32_t CONVERSION_REQUEST_DELAY = 750;

static const int32_t NTP_OFFSET = 3600; // GMT+1
#endif

## Commit log

2019-02-23 display pcb
2019-02-23 rst pin for nano
2019-02-23 update pcb
2019-09-15 Single PCB scheme
2019-10-01 Fix formating
2020-02-17 PlatformIO project initialization
2020-02-29 Display + wifi
2020-03-08 Display and input drivers
2020-03-08 basic gui + wifi
2020-03-10 basics working
2020-03-10 status led improvement
2020-03-10 burner + valve control fix
2020-06-12 Fixed I2C race conditions
2020-06-12 Fix platformio libdeps versions
2020-06-12 Manual motor control, changed NTPClient library to built in time.h library + bug fixes
2024-10-03 feat: Move first complete version of buderus-controller to this repositroy
2024-10-03 chore: Move DS2482 library to be handled by platformio
2024-10-05 feat: Allow instant heating state transtitions in heating control loop
2024-10-05 edit: Change Info page text
2024-10-05 rework: Improve GUI to use smooth fonts and add temp gauges on main screen
2024-10-05 edit: Update readme to show image of new UI
2024-10-05 cleanup: Remove `setTextSize` calls that now have no effect
